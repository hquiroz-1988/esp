/**
 *******************************************************************************
 * @file    mutex.cpp
 * @author  HQ
 * @date    2025-10-29 22:33:32
 * @brief   
 *******************************************************************************
 */

/*******************************************************************************
 * INCLUDES
*******************************************************************************/
#include "mutex.hpp"

/*******************************************************************************
 * EXTERN VARIABLES
 *******************************************************************************/

/*******************************************************************************
 * PRIVATE MACROS AND DEFINES
 *******************************************************************************/

/*******************************************************************************
 * PRIVATE TYPEDEFS
 *******************************************************************************/

/*******************************************************************************
 * STATIC VARIABLES
 *******************************************************************************/

/*******************************************************************************
 * GLOBAL VARIABLES
 *******************************************************************************/

/*******************************************************************************
 * STATIC FUNCTION PROTOTYPES
 *******************************************************************************/

/*******************************************************************************
 * STATIC FUNCTIONS
 *******************************************************************************/

/*******************************************************************************
 * GLOBAL FUNCTIONS
 *******************************************************************************/
Mutex::Mutex()
{
    // Constructor implementation
}

Mutex::~Mutex()
{
    // Destructor implementation
}

Status_t Mutex::create()
{
    Status_t status = STATUS_OS_ERROR;

    if(mutex == nullptr)
    {
        mutex = xSemaphoreCreateMutex();
        if (mutex != nullptr)
        {
            status = STATUS_OKAY;
        }
    }
    
    return status;
}

Status_t Mutex::lock()
{
    Status_t status = STATUS_OS_ERROR;

    if (xSemaphoreTake(mutex, portMAX_DELAY) == pdTRUE)
    {
        status = STATUS_OKAY;
    }

    return status;
}

Status_t Mutex::unlock()
{
    Status_t status = STATUS_OS_ERROR;

    if (xSemaphoreGive(mutex) == pdTRUE)
    {
        status = STATUS_OKAY;
    }

    return status;
}